# Keil uVision project VGASource.uvprojx, settings and files
target VGASource (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F425F8P7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: VGASource +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F425F8P7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f425_int.c at32f425_wk_config.c main.c wk_system.c
  group firmware
    ../../libraries/drivers/src/: at32f425_crm.c at32f425_debug.c at32f425_flash.c at32f425_gpio.c at32f425_misc.c at32f425_pwc.c
  group cmsis
    ./: startup_at32f425.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f425.c
